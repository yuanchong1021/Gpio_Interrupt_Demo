# IAR project Gpio_Interrupt_Demo.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: YTM32B1LE15 YTM32B1LE15
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: YTM32B1LE1; CPU_YTM32B1LE1
  ICCARM.CCIncludePath2: ../board; ../platform/drivers/src/clock/YTM32B1Lx; ../platform/drivers/src/pins; ../platform/drivers/src/dma; ../platform/drivers/src/uart; ../platform/drivers/inc; ../platform/devices/common; ../platform/devices; ../platform/devices/YTM32B1LE1/include; ../platform/devices/YTM32B1LE1/startup; ../CMSIS/Core/Include; ../rtos/osif; ../middleware/utility_flash_ecc_fault; ../middleware/utility_print/printf
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Gpio_Interrupt_Demo.hex
  ILINK.IlinkOutputFile: Gpio_Interrupt_Demo.out
  ILINK.IlinkIcfFile: ../board/yt_linker.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group app
    ../app/: main.c
  group board
    ../board/: clock_config.c clock_config.h pin_mux.c pin_mux.h yt_linker.icf RamInit0.S RamInit1.c RamInit2.c startup.S vector.S vector_table_copy.c interrupt_config.c interrupt_config.h dma_config.c dma_config.h uart_config.c uart_config.h utility_flash_ecc_fault_config.h utility_flash_ecc_fault_config.c utility_print_config.h utility_print_config.c sdk_project_config.h
  group CMSIS/Core/Include
    ../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_ccarm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group platform/drivers/src/clock/YTM32B1Lx
    ../platform/drivers/src/clock/YTM32B1Lx/: cfmu_hw_access.h clock_YTM32B1Lx.c clock_YTM32B1Lx.h cmu_hw_access.h ipc_hw_access.h scu_hw_access.h
  group platform/drivers/src/clock/YTM32B1Lx/doxygen
    ../platform/drivers/src/clock/YTM32B1Lx/doxygen/: clock_YTM32B1Lx.dox
  group platform/drivers/src/pins
    ../platform/drivers/src/pins/: pins_driver.c pins_gpio_hw_access.h pins_port_hw_access.c pins_port_hw_access.h
  group platform/drivers/src/pins/doxygen
    ../platform/drivers/src/pins/doxygen/: pins.dox
  group platform/drivers/src/interrupt
    ../platform/drivers/src/interrupt/: interrupt_manager.c
  group platform/drivers/src/interrupt/doxygen
    ../platform/drivers/src/interrupt/doxygen/: interrupt.dox
  group platform/drivers/src/dma
    ../platform/drivers/src/dma/: dma_driver.c dma_hw_access.c dma_hw_access.h dma_irq.c dma_irq.h
  group platform/drivers/src/dma/doxygen
    ../platform/drivers/src/dma/doxygen/: dma_driver.dox
  group platform/drivers/src/uart
    ../platform/drivers/src/uart/: uart_driver.c uart_irq.c uart_irq.h uart_hw_access.h uart_hw_access.c
  group platform/drivers/inc
    ../platform/drivers/inc/: clock.h clock_manager.h pins_driver.h interrupt_manager.h dma_driver.h uart_driver.h
  group platform/devices
    ../platform/devices/: callbacks.h devassert.h device_registers.h floats.h status.h
  group platform/devices/common
    ../platform/devices/common/: core_common.h
  group platform/devices/YTM32B1LE1/include
    ../platform/devices/YTM32B1LE1/include/: YTM32B1LE1.h YTM32B1LE1_features.h
  group platform/devices/YTM32B1LE1/startup
    ../platform/devices/YTM32B1LE1/startup/: system_YTM32B1LE1.c system_YTM32B1LE1.h
  group rtos/osif
    ../rtos/osif/: osif.h osif_baremetal.c
  group middleware/utility_flash_ecc_fault
    ../middleware/utility_flash_ecc_fault/: flash_ecc_fault.c flash_ecc_fault.h flash_ecc_fault_asm.S
  group middleware/utility_print/printf
    ../middleware/utility_print/printf/: printf.c printf.h
